<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Exerc_20\src\Exerc_20.ewp</path>
    </project>
    <batchBuild />
</workspace>
